R1 n1 n2 1.04765357286k
R2 n3 n2 2.06140068334k
R3 n2 n5 3.03459085363k
R4 n5 0 4.00398818216k
R5 n5 n6 3.11499853456k
R6 0 n7 2.04588646991k
R7 n7 n8 1.04390152967k
Vs n1 0 DC 5.02522591213
V0 n8 n9 DC 0
C0 n6 n8 1.00982536324u
G0 n6 n3 n2 n5 7.28209304852m
H0 n5 n9 V0 8.36641247715k
