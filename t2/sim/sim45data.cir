R1 n1 n2 1.047654k
R2 n3 n2 2.061401k
R3 n2 n5 3.034591k
R4 n5 0 4.003988k
R5 n5 n6 3.114999k
R6 0 n7 2.045886k
R7 n9 n8 1.043902k
Vs n1 0 0.0 ac 1.0 sin(0 1 1k)
V0 n7 n9 DC 0
C0 n6 n8 1.009825u
G0 n6 n3 n2 n5 7.282093m
H0 n5 n8 V0 8.366412k
.ic v(n6) = 8.49302e00
.ic v(n8) = 0
